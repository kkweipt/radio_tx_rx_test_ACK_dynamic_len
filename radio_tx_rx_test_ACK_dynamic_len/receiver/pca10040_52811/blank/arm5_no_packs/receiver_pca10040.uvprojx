# Keil uVision project receiver_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52811_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.27.1
  cpu: IRAM(0x20000000,0x00006000) IROM(0x00000000,0x00030000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_SOFT  xNRF52 xNRF52832_XXAA     NRF52811_XXAA   NRF52_PAN_74 SWI_DISABLE0 __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\..\components\drivers_nrf\radio_config;..\..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\..\components\libraries\util;..\..\..;..\..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\..\modules\nrfx\mdk;..\config
  asm define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_SOFT    xNRF52 xNRF52832_XXAA     NRF52811_XXAA      NRF52_PAN_74 SWI_DISABLE0 __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DSWI_DISABLE0,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x6000
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../../components/libraries/bsp/: bsp.c
  group nRF_Drivers
    ../../../../../../../integration/nrfx/legacy/: nrf_drv_uart.c
    ../../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../../modules/nrfx/drivers/src/: nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c
    ../../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../../../../../../components/drivers_nrf/radio_config/: radio_config.c
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.27.1
